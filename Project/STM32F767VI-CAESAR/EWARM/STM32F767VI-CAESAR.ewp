# IAR project STM32F767VI-CAESAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767VI ST STM32F767VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F767xx; OS_SYS_INIT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\Utilities\f-scaling; ..\..\..\benchmarking
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32F767VI-CAESAR.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\Goragod\Desktop\Workspace\STM32F7\Project\STM32F767VI-CAESAR\EWARM\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F767xx
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; C:\Users\Goragod\Desktop\Workspace\STM32F7\Utilities\f-scaling
  AARM.AUserIncludes: ..\inc
  ILINK.IlinkIcfFile: C:\Users\Goragod\Desktop\Workspace\STM32F7\Drivers\CMSIS\Device\ST\STM32F7xx\Source\Templates\iar\linker\stm32f767xx_flash.icf
  group Benchmark
    ../../../benchmarking/: bb_sort.c bb_sort.h
  group CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f767xx.s
    ../src/: system_stm32f7xx.c
  group LL_Periph_Drivers/inc
    ../../../Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_dma.h stm32f7xx_ll_gpio.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_system.h stm32f7xx_ll_utils.h
  group LL_Periph_Drivers/src
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_adc.c stm32f7xx_ll_dma.c stm32f7xx_ll_gpio.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c
  group User
    ../src/: main.c stm32f7xx_it.c sys_macro.c
  group Utilities/Task Supervisor
    ../../../Utilities/f-scaling/: current_meas.c current_meas.h fmap.c perf_config.c perf_config.h task_supervisor.c task_supervisor.h
  group Utilities/Third Party/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c
  group Utilities/Third Party/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
