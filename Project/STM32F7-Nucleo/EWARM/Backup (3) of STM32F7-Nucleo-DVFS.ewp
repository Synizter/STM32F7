# IAR project Backup (3) of STM32F7-Nucleo-DVFS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\Middlewares\Third_Party\lwip-2.0.2\src\include; ..\..\..\Middlewares\Third_Party\lwip-2.0.2\contrib-2.0.1\ports\stm32f7xx_freertos\include; ..\..\..\Drivers\STM32F7xx_ETH_Driver\inc; ..\..\..\Utilities\f-scaling
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Include
  ILINK.IlinkOutputFile: STM32F7-Nucleo-DVFS.out
  ILINK.IlinkIcfFile: stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ./: startup_stm32f767xx.s
    ../Source/: system_stm32f7xx.c
  group Driver/STM32F7xx_ETH_Driver
    ../../../Drivers/STM32F7xx_ETH_Driver/src/: stm32f7xx_eth.c
  group Driver/STM32F7xx_LL_Driver
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_OS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/LwIP/api
    ../../../Middlewares/Third_Party/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/core
    ../../../Middlewares/Third_Party/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/core/ipv4
    ../../../Middlewares/Third_Party/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/netif
    ../../../Middlewares/Third_Party/lwip-2.0.2/src/netif/: ethernet.c slipif.c
  group Middlewares/LwIP/port
    ../../../Middlewares/Third_Party/lwip-2.0.2/contrib-2.0.1/ports/stm32f7xx_freertos/: ethernetif.c sys_arch.c
  group User
    ../Include/: FreeRTOSConfig.h
    ../Source/: main.c stm32f7xx_it.c
  group User/F-Scaling
    ../../../Utilities/f-scaling/: perf_config.c perf_config.h task_supervisor.c task_supervisor.h
  group User/Network
    ../Source/: stm32f7xx_eth_bsp.c stm32f7xx_eth_netconf.c
