# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F765VG ST STM32F765VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F765xx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; C:\Users\Goragod\Desktop\STM32F7\Utilities\f-scaling; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\Middlewares\Third_Party\FreeRTOS; ..\inc
  ILINK.IlinkOutputFile: Project.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f765xx.s
    ../src/: system_stm32f7xx.c
  group Driver/STM32F7xx_LL_Driver
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_spi.c stm32f7xx_ll_usart.c stm32f7xx_ll_utils.c
  group Driver/STM32F7xx_LL_Driver/include
    ../../../Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_ll_bus.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_utils.h
  group Middleware/f-scalin
    ../../../Utilities/f-scaling/: fmap.c perf_config.c task_supervisor.c
  group Middleware/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middleware/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group User
    ../src/: main.c stm32f7xx_it.c
