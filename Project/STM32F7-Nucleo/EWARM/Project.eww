<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F7-Nucleo-DVFS.ewp</path>
    </project>
    <batchBuild />
</workspace>
